# Set the root filesystem to the partition mender selects
KERNEL_ROOT_SD = "root=\${mender_kernel_root} ro rootwait"
