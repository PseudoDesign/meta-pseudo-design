DESCRIPTION = "Packagegroup for pseudo-design host platforms"

inherit packagegroup

RDEPENDS:${PN} = "\
    openvpn \
    "
