
LICENSE = "MIT"
inherit core-image

IMAGE_INSTALL = "packagegroup-pd-host"